require viper-buildimage_${PV}.bb
inherit native
